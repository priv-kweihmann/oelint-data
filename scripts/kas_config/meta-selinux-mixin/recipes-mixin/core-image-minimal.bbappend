inherit selinux-image
