LICENSE = "CLOSED"
inherit swupdate
