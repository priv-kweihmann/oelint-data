LICENSE = "CLOSED"
inherit swupdate-image
